.title KiCad schematic
.include "models/B3100.spice.txt"
.include "models/BZX84C4V7.spice.txt"
.include "models/C2012C0G2A102J060AA_p.mod"
.include "models/C2012X7R2A104K125AA_p.mod"
.include "models/C2012X7R2E103K125AA_p.mod"
.include "models/C3216X7R2E104K160AA_p.mod"
.include "models/C3225X7R2A105K200AA_p.mod"
.include "models/MAX16832C.LIB"
.include "models/MAX4080T.FAM"
.include "models/TLC2272.LIB"
.include "models/TVS_Diode_SMAJxxx_CA_SPICE_Model_txt.txt"
.include "models/XLamp-XML-spice.txt"
.include "models/ntc_20130313.lib"
V103 VCC 0 {vsource}
V102 /CTRL 0 PULSE(0 {vsupply} {delay} {tr} {tf} {duty} {cycle})
XU101 VCC 0 C3225X7R2A105K200AA_p
XU102 VCC 0 C2012X7R2A104K125AA_p
XU104 /A VCC 0 0 /LX /CTRL /TEMP MAX16832C
R102 /TEMP /NTC 20k
XU113 /NTC 0 C2012X7R2E103K125AA_p
L101 /LX /K 220u Rser=0.193
D105 /LX VCC DI_B3100
R106 /A VCC 0.5
R105 /A VCC 0.5
R103 /CURRENT_FEEDBACK /VOCM 1k
V101 VAA 0 {vsupply}
XU103 0 VAA C2012X7R2A104K125AA_p
XU105 /NTC /TEMPERATURE_FEEDBACK VAA 0 /TEMPERATURE_FEEDBACK TLC2272
XU112 /NTC 0 B57452V5104J062
XU111 VCC 0 C2012X7R2A104K125AA_p
R107 VCC /SP 20
R104 /A /SN 20
XU109 /SN /SP C2012C0G2A102J060AA_p
XU110 /SP VCC NC_01 0 /VOCM NC_02 NC_03 /SN MAX4080T
XU106 /CURRENT_FEEDBACK 0 C2012X7R2E103K125AA_p
XU107 /A /K C3216X7R2E104K160AA_p
XD104 0 /CURRENT_FEEDBACK DI_BZX84C4V7
XD103 0 /TEMPERATURE_FEEDBACK DI_BZX84C4V7
XU108 /A /K SMAJ75CA
D201 /A /LOAD/1 XM
D202 /A /LOAD/1 XM
D207 /LOAD/1 /LOAD/2 XM
D208 /LOAD/1 /LOAD/2 XM
D213 /LOAD/2 /LOAD/3 XM
D214 /LOAD/2 /LOAD/3 XM
D219 /LOAD/3 /LOAD/4 XM
D220 /LOAD/3 /LOAD/4 XM
D225 /LOAD/4 /LOAD/5 XM
D226 /LOAD/4 /LOAD/5 XM
D231 /LOAD/5 /LOAD/6 XM
D232 /LOAD/5 /LOAD/6 XM
D235 /LOAD/6 /LOAD/7 XM
D236 /LOAD/6 /LOAD/7 XM
D239 /LOAD/7 /LOAD/8 XM
D240 /LOAD/7 /LOAD/8 XM
D203 /LOAD/8 /LOAD/9 XM
D204 /LOAD/8 /LOAD/9 XM
D209 /LOAD/9 /LOAD/10 XM
D210 /LOAD/9 /LOAD/10 XM
D215 /LOAD/10 /LOAD/11 XM
D216 /LOAD/10 /LOAD/11 XM
D221 /LOAD/11 /LOAD/12 XM
D222 /LOAD/11 /LOAD/12 XM
D227 /LOAD/12 /LOAD/13 XM
D228 /LOAD/12 /LOAD/13 XM
D233 /LOAD/13 /LOAD/14 XM
D234 /LOAD/13 /LOAD/14 XM
D237 /LOAD/14 /LOAD/15 XM
D238 /LOAD/14 /LOAD/15 XM
D241 /LOAD/15 /LOAD/16 XM
D242 /LOAD/15 /LOAD/16 XM
D205 /LOAD/16 /LOAD/17 XM
D206 /LOAD/16 /LOAD/17 XM
D211 /LOAD/17 /LOAD/18 XM
D212 /LOAD/17 /LOAD/18 XM
D217 /LOAD/18 /LOAD/19 XM
D218 /LOAD/18 /LOAD/19 XM
D223 /LOAD/19 /LOAD/20 XM
D224 /LOAD/19 /LOAD/20 XM
D229 /LOAD/20 /K XM
D230 /LOAD/20 /K XM
.end
